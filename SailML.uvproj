# Keil uVision project SailML.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: SailML +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User;.\SailFwLib;.\SailFwLib\src\STC8H;.\SailFwLib\inc;.\SailFwLib\lib
  group User
    ./User/: main.c sl_config.h
  group SailFwLib
    ./SailFwLib/: License README SailFwLib.h sl_stc8h.h
  group STC8H
    ./SailFwLib/src/STC8H/: gpio.c sys.c
  group inc
    ./SailFwLib/lib/: stc8h.h
    ./SailFwLib/inc/: gpio.h isr.h README sys.h type.h
